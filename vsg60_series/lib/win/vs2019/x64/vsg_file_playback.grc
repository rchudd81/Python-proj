options:
  parameters:
    generate_options: no_gui
    id: vsg_file_playback
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Richard\SatEMU\TransEMU\my-sdr-tools\iq\psk_BPSK_0Hz_1200sym_ro0.35.sdriq
    repeat: 'True'
    type: complex
  states: {}
- name: soapy_custom_sink_0
  id: soapy_custom_sink
  parameters:
    center_freq0: 1e9
    driver: vsg
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', soapy_custom_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
